Commit message: chairman

File: urdf2usd_convert/g1/urdf/cube_2.urdf (robot description, URDF)
Before this commit: robot cube_2, 1 links, 0 joints
Links:
- removed link cube_2_link
- added link cube, mass 1.0; collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
