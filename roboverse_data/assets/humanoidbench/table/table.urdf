Commit message: working g1_IK_solver for mujoco

File: roboverse_data/assets/humanoidbench/table/table.urdf (robot description, URDF)
Before this commit: robot table, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1.2 1.0 0.05; visual mesh filename=meshes/table.obj
